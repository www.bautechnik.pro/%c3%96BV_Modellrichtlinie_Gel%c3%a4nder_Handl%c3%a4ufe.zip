Properties of the parts of a building model (IFC4)

# File
Description: no view
File name: ÖBV_OEBV_Richtlinie_Geländer_Handläufe.ifc
Time: 2024-03-13T09:50:22
Author: Oesterreichische Bautechnik Vereinigung
Organization: OEBV
Written by: ODA SDAI 24.5
Authorization: OEBV

# IfcSite, Liegenschaft
RefLatitude: 48, 8, 10, 320000; RefLongitude: 11, 41, 19, 320000

# IfcBuildingStorey, Geschoss 01
In: Gebäude
Elevation: 0 m

# IfcElementAssembly
In: Geschoss 01
AllplanAttributes - Allright_Bauteil_ID: 0022Elg0000012673

# IfcRailing (51)
In: Geschoss 01
Name | Allright_Bauteil_ID
 | 0022ErE0000012672
 | 0022ErE0000007508
 | 0022ErE0000007509
 | 0022ErE0000007510
 | 0022ErE0000007511
 | 0022ErE0000007512
 | 0022ErE0000007514
 | 0022ErE0000007516
 | 0022ErE0000007517
 | 0022ErE0000007518
 | 0022ErE0000007519
 | 0022ErE0000007520
 | 0022ErE0000007522
 | 0022ErE0000007524
 | 0022ErE0000007525
 | 0022ErE0000007526
 | 0022ErE0000007527
 | 0022ErE0000007528
 | 0022ErE0000007530
 | 0022ErE0000007532
 | 0022ErE0000007533
 | 0022ErE0000007534
 | 0022ErE0000007535
 | 0022ErE0000007536
 | 0022ErE0000007538
 | 0022ErE0000007542
 | 0022ErE0000007543
 | 0022ErE0000007544
 | 0022ErE0000007545
 | 0022ErE0000007560
 | 0022ErE0000007561
 | 0022ErE0000007562
 | 0022ErE0000007563
 | 0022ErE0000007578
 | 0022ErE0000007579
 | 0022ErE0000007580
 | 0022ErE0000007581
 | 0022ErE0000007596
 | 0022ErE0000007597
 | 0022ErE0000007598
 | 0022ErE0000007599
 | 0022ErE0000007602
 | 0022ErE0000007603
 | 0022ErE0000007604
 | 0022ErE0000007605
 | 0022ErE0000007506
 | 0022ErE0000007671
 | 0022ErE0000007672
 | 0022ErE0000007673
 | 0022ErE0000007674
 | 0022ErE0000007675

# IfcStair, Treppe
In: Geschoss 01
PredefinedType: STRAIGHT_RUN_STAIR
AllplanAttributes - Allright_Bauteil_ID: 0022Tre0000000003
